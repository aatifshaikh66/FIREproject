# Keil uVision project Templates_LL.uvprojx, settings and files
target Templates_LL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G030K6Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FDSS_FINAL_V3 +hex
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin --output=C:\Users\DELL\Desktop\WORK\OFFICE_MAIN\FIRE\PROJECT\Projects\_MAIN_Project\MDK-ARM\Templates_LL\bin\FDSS.bin C:\Users\DELL\Desktop\WORK\OFFICE_MAIN\FIRE\PROJECT\Projects\_MAIN_Project\MDK-ARM\Templates_LL\Exe\FDSS_FINAL_V3.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=48000000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G030xx
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc;..\..\..\Drivers\STM32G0xx_HAL_Driver\Src;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c SystemInit.c app.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_dac.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
software components: CMSIS:CORE 5.4.0
